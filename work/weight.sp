Vinx0y0 nx0y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 0 1 1 0 1 1 1 1 1 0 1 0 0 0 1 1 1 1 1 1 0 0 0 0 0 1 0 0
Vinx0y1 nx0y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 1 1 0 1 0 0 1 0 0 1 1 1 0 0 0 0 1 1 1 0 0 1 1 1 1 1 0
Vinx0y2 nx0y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 1 0 1 0 1 1 1 0 1 1 1 1 0 1 0 1 0 0 1 1 0 0 1 0 1 1 0 0 0
Vinx0y3 nx0y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*1 1 1 1 1 1 0 0 0 1 0 1 0 0 1 0 0 1 1 1 0 0 0 1 1 1 0 0 0 0
Vinx1y0 nx1y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 1 1 0 0 1 1 0 1 0 1 1 1 0 0 0 0 1 1 0 0 1 1 0 0 1 1 0
Vinx1y1 nx1y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 1 0 1 1 0 1 0 1 1 0 0 1 1 1 0 0 1 0 0 0 1 0 1 0 0 1
Vinx1y2 nx1y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 1 0 1 1 1 1 1 0 1 1 1 1 1 1 0 1 0 1 1 0 0 1 1 0 1 1 0
Vinx1y3 nx1y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 1 1 0 1 1 0 1 1 0 0 0 0 0 0 1 0 1 0 0 1 0 1 0 1 0 1 0 0
Vinx2y0 nx2y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 1 0 0 0 1 1 1 1 0 0 1 0 1 0 0 1 0 1 1 0 1 1 0 0 1 0
Vinx2y1 nx2y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 0 0 0 1 0 0 1 0 0 1 1 1 1 0 1 1 0 0 0 0 1 1 1 0 0 1
Vinx2y2 nx2y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 0 1 0 0 0 1 1 1 0 0 1 1 0 0 0 1 1 0 0 1 1 1 1 0 1 1 0 0
Vinx2y3 nx2y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 0 1 1 1 1 1 0 1 1 1 1 0 1 0 1 1 0 1 1 1 0 0 0 1 0 1 0 0 0
Vinx3y0 nx3y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 0 0 1 1 0 0 0 0 1 0 0 0 0 0 0 0 1 0 1 1 0 0 0 1 1 1
Vinx3y1 nx3y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 0 1 1 1 1 0 0 0 1 1 0 1 0 1 1 1 0 0 0 1 1 1 0 0 1 1
Vinx3y2 nx3y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 1 0 0 0 0 1 1 0 0 0 0 0 0 0 1 0 1 0 0 1 1 1 1 1 0 1 0 0 0
Vinx3y3 nx3y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 0 1 0 0 1 1 1 1 0 0 1 1 0 1 1 1 1 0 1 0 1 0 1 1 1 1
Vinx4y0 nx4y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 1 0 0 0 0 0 0 0 1 1 1 0 1 0 0 0 0 0 1 1 1 0 1 1 1
Vinx4y1 nx4y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 1 0 0 1 0 0 0 0 0 1 0 1 0 0 1 1 0 0 1 0 0 0 1 1 0 1
Vinx4y2 nx4y2 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 1 0 1 0 1 1 1 0 1 0 0 1 1 1 0 1 0 1 1 1 1 0 0 0 1 0 1
Vinx4y3 nx4y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 0 0 1 1 1 1 1 0 0 0 0 0 0 0 1 0 0 1 1 1 1 1 0 0 1 1
Vinx5y0 nx5y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 1 1 0 1 1 1 1 1 1 1 0 1 1 1 1 0 0 1 1 1 0 0 1 0 0 1 0
Vinx5y1 nx5y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 1 1 0 0 0 1 1 1 1 1 1 1 0 0 1 0 1 1 0 0 1 1 0 0 1 0
Vinx5y2 nx5y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 0 0 1 1 1 0 0 0 1 1 0 1 0 1 1 1 0 1 0 0 1 1 1 1 1 1
Vinx5y3 nx5y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 1 1 1 1 1 1 1 0 0 1 0 0 0 0 0 0 1 0 0 1 0 1 0 1 1 1 0
Vinx6y0 nx6y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 1 1 0 1 1 1 1 1 1 0 1 1 0 0 0 1 0 1 1 0 1 1 1 1 1 0 0
Vinx6y1 nx6y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 1 0 0 0 0 0 0 0 0 1 0 0 0 0 1 0 1 0 1 0 0 0 1 1 0 1
Vinx6y2 nx6y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 1 1 1 1 0 1 1 0 0 0 1 1 1 1 1 1 0 0 1 1 0 1 1 1 0 1
Vinx6y3 nx6y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 0 1 1 0 0 1 0 1 1 0 1 1 1 0 1 1 1 0 0 0 1 0 0 0 0 1
Vinx7y0 nx7y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 1 0 0 1 0 0 0 0 0 0 1 0 0 1 1 1 0 1 0 0 0 1 0 0 1 1 0
Vinx7y1 nx7y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 1 0 0 0 1 1 0 0 0 1 0 0 0 1 0 0 1 1 0 1 1 1 0 0 1 1
Vinx7y2 nx7y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 1 1 1 0 0 1 1 1 0 1 0 0 1 0 1 1 0 1 1 0 1 1 1 0 1 1
Vinx7y3 nx7y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 1 0 0 1 0 0 1 0 0 0 0 1 1 0 0 0 1 1 1 0 1 0 1 0 0 1 0 0 0
Vinx8y0 nx8y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 1 1 0 1 1 0 0 0 0 0 0 0 1 1 0 1 1 0 1 1 1 1 1 0 0 1
Vinx8y1 nx8y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 1 1 1 1 1 0 0 1 1 1 0 1 0 0 0 0 0 0 0 1 1 1 0 0 0 1
Vinx8y2 nx8y2 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 1 1 0 0 1 1 1 1 1 1 1 0 0 1 0 0 1 1 0 0 0 1 0 0 0 0 1
Vinx8y3 nx8y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 1 0 1 1 1 0 0 0 1 1 1 1 1 1 1 0 1 0 1 0 0 1 1 1 0 1
Vinx9y0 nx9y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 1 1 0 0 0 0 0 1 1 0 1 0 0 0 0 0 1 1 0 1 0 0 1 1 1 1 0
Vinx9y1 nx9y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 0 0 0 1 0 0 1 1 1 0 1 0 0 0 1 0 0 0 0 0 0 1 1 1 1 1
Vinx9y2 nx9y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 1 0 1 0 1 0 1 1 0 0 0 0 0 1 0 1 0 0 0 1 0 0 0 0 0 1
Vinx9y3 nx9y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 1 1 0 1 1 1 1 0 0 1 0 0 0 1 1 1 1 0 1 1 1 0 0 0 1 1
Vinx10y0 nx10y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 0 1 1 1 1 1 1 0 0 1 1 0 1 0 1 1 0 1 0 1 0 0 1 0 1 1
Vinx10y1 nx10y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 1 1 0 0 0 1 1 1 0 1 1 1 1 0 1 1 0 1 0 0 0 1 1 0 0 1 0
Vinx10y2 nx10y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 1 1 0 1 1 0 0 0 1 1 1 0 1 0 0 0 0 0 0 0 0 1 0 0 0 1
Vinx10y3 nx10y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*0 1 0 1 1 1 0 1 0 1 1 0 0 0 0 0 0 0 0 1 1 1 1 1 1 1 0 0 0 0
Vinx11y0 nx11y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 1 1 0 1 1 1 0 0 1 1 1 0 1 1 1 0 1 0 1 1 1 0 1 1 1
Vinx11y1 nx11y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 1 1 0 1 0 0 1 1 0 1 1 0 0 1 1 1 0 1 1 1 1 0 0 0 1 1 0
Vinx11y2 nx11y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 1 0 1 0 0 1 1 0 0 0 1 1 0 0 1 1 0 0 1 0 1 0 0 1 1 1
Vinx11y3 nx11y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 1 0 0 0 0 1 1 1 1 0 0 0 0 1 1 0 0 0 1 1 1 0 0 1 0 1
Vinx12y0 nx12y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 0 1 1 0 0 1 1 1 1 0 0 0 1 0 1 1 1 0 1 0 0 1 0 1 1 1 0
Vinx12y1 nx12y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 1 0 1 0 1 0 0 1 0 1 1 1 0 1 1 0 0 0 0 0 0 1 0 0 1
Vinx12y2 nx12y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 1 1 0 1 0 0 0 1 1 0 1 1 0 1 0 1 0 0 0 0 1 0 1 0 1
Vinx12y3 nx12y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 1 0 0 0 1 1 1 1 1 0 0 0 1 0 0 1 0 1 1 1 1 0 0 1 0 0 1
Vinx13y0 nx13y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 0 0 0 0 0 1 1 1 1 1 0 0 1 0 1 0 0 0 1 1 1 0 0 0 1 1 0
Vinx13y1 nx13y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 0 0 1 1 0 0 1 1 0 1 0 0 1 1 1 1 0 1 1 0 0 1 1 0 0 1
Vinx13y2 nx13y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 0 0 1 1 1 0 1 1 1 1 0 1 0 0 0 0 1 1 0 0 1 1 1 0 1 1
Vinx13y3 nx13y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 0 1 1 0 0 1 0 0 0 1 0 0 0 0 1 1 1 0 0 0 1 1 1 0 0 1
Vinx14y0 nx14y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 1 0 1 0 1 1 0 0 0 0 1 1 1 1 1 0 1 0 1 0 1 0 1 1 0 1 0 0 0
Vinx14y1 nx14y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 0 1 1 0 1 1 0 1 0 1 1 0 0 0 0 1 0 1 1 1 0 0 1 0 1 1
Vinx14y2 nx14y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 1 0 1 0 1 1 1 0 0 1 1 1 0 1 0 0 1 1 0 1 0 1 1 0 1
Vinx14y3 nx14y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 0 1 1 0 1 1 1 1 1 1 1 1 0 1 1 1 0 0 1 0 1 0 0 0 0 1 0 0
Vinx15y0 nx15y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 1 1 1 0 1 1 0 0 0 1 0 0 0 1 0 0 0 0 1 0 0 0 0 1 0 1
Vinx15y1 nx15y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 1 1 0 0 0 0 0 1 0 1 0 0 0 0 0 1 0 1 0 0 0 1 1 1 1 1
Vinx15y2 nx15y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 0 1 1 1 1 1 1 0 0 0 1 0 0 0 0 1 0 0 0 0 0 1 1 0 0 1
Vinx15y3 nx15y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 0 0 1 1 0 0 0 0 0 1 0 1 1 0 0 0 0 0 0 1 0 0 0 1 1
Vinx16y0 nx16y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 0 0 0 0 0 0 0 1 0 0 0 1 0 0 0 0 1 1 0 1 0 0 1 0 1 1
Vinx16y1 nx16y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 0 1 1 1 0 0 0 1 0 1 1 0 1 1 0 0 0 1 1 1 1 1 1 0 1
Vinx16y2 nx16y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 1 0 1 0 1 1 0 0 0 1 1 1 1 0 1 1 0 1 1 0 1 1 1 1 1 1 0 0
Vinx16y3 nx16y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 0 1 1 0 1 0 0 1 0 1 1 1 0 0 1 1 1 1 1 0 1 1 0 0 0 1 0
Vinx17y0 nx17y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 0 1 1 1 1 1 0 1 0 1 0 1 1 0 0 0 0 1 0 1 0 0 1 0 1
Vinx17y1 nx17y1 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 1 0 0 1 0 1 1 1 0 1 0 0 0 1 1 0 0 1 1 0 1 0 1 0 1 1 0
Vinx17y2 nx17y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 0 0 0 0 1 0 0 0 0 1 0 1 0 1 0 1 1 0 0 0 1 0 0 0 1 1 0
Vinx17y3 nx17y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 1 0 0 0 0 1 1 0 1 1 1 1 0 0 1 1 1 0 1 1 1 0 0 0 0 1 1
Vinx18y0 nx18y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 1 1 1 1 0 1 1 1 1 0 0 0 0 1 0 0 1 0 0 1 1 1 0 1 0 1 0 0 0
Vinx18y1 nx18y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 0 1 0 1 0 1 0 1 1 1 1 1 1 0 0 0 0 0 1 1 1 1 1 1 1 1 0 0 0
Vinx18y2 nx18y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 1 0 0 1 0 0 1 0 1 1 0 0 1 1 1 0 1 1 0 0 0 0 1 0 1 0
Vinx18y3 nx18y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 0 1 0 1 0 1 1 1 0 1 0 0 1 0 1 0 0 0 0 0 1 1 0 1 0 1
Vinx19y0 nx19y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 1 1 0 0 0 0 0 1 1 1 1 1 0 1 1 0 0 1 1 1 1 1 0 1 1 1 0
Vinx19y1 nx19y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 1 1 0 1 0 1 1 0 0 0 0 0 0 1 1 1 0 1 1 0 0 0 0 0 1 1 0 0 0
Vinx19y2 nx19y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 0 0 0 1 1 0 1 1 1 1 0 1 0 1 0 0 1 0 1 0 0 1 0 1 0 1
Vinx19y3 nx19y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 0 1 1 1 0 1 0 0 0 1 1 0 1 0 0 1 1 0 1 0 1 1 0 1 1 1
Vinx20y0 nx20y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 1 1 0 1 1 0 1 0 1 1 0 0 0 0 1 0 1 1 1 0 1 0 1 1 0 1 0
Vinx20y1 nx20y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*1 1 1 1 0 0 0 0 0 0 0 0 0 0 1 0 0 0 1 1 0 1 0 1 1 1 0 0 0 0
Vinx20y2 nx20y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 1 1 1 1 0 0 0 0 0 1 1 0 0 0 0 0 1 1 1 0 0 1 1 0 0 0 1
Vinx20y3 nx20y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 1 1 0 1 1 1 1 1 0 1 0 0 1 1 1 0 1 1 1 0 1 1 1 0 1
Vinx21y0 nx21y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 0 0 0 0 0 1 0 1 1 0 0 1 1 0 1 0 0 0 0 0 0 0 0 1 0 1
Vinx21y1 nx21y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 0 0 0 1 0 0 0 0 0 1 1 0 1 0 0 1 1 1 1 1 1 0 0 0 0 1 0 0 0
Vinx21y2 nx21y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 1 0 1 1 0 1 1 0 1 0 1 1 0 0 1 0 1 0 0 0 0 0 0 1 0 1
Vinx21y3 nx21y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 1 0 1 0 1 1 0 0 0 0 1 0 1 1 1 1 0 0 0 1 0 1 0 0 1 0 0
Vinx22y0 nx22y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 0 1 0 1 1 0 0 0 1 0 1 0 0 0 1 1 1 1 0 1 0 1 0 1 1 1 1 0
Vinx22y1 nx22y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 1 1 0 1 0 1 1 1 0 1 0 1 1 1 0 1 1 0 1 1 1 0 0 0 1
Vinx22y2 nx22y2 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 1 1 1 0 0 0 1 0 1 1 1 1 1 1 0 1 0 1 0 0 0 0 1 1 1 1
Vinx22y3 nx22y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 0 1 0 0 1 1 0 1 1 1 0 0 0 0 1 0 1 0 0 1 0 0 0 1 0 1 0
Vinx23y0 nx23y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 0 1 1 1 1 1 0 0 1 1 1 0 0 0 1 1 1 0 0 1 0 0 1 1 0 1 0
Vinx23y1 nx23y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 1 0 1 0 1 1 1 0 1 0 0 0 0 0 1 1 0 1 0 1 0 0 0 1 1 1 0 0
Vinx23y2 nx23y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 1 1 0 0 0 0 0 1 1 0 1 1 1 0 1 1 1 0 1 1 0 0 1 1 0 1
Vinx23y3 nx23y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 0 0 0 0 1 0 0 1 1 0 0 0 0 0 0 0 0 1 1 0 0 1 0 0 1
Vinx24y0 nx24y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 0 1 0 0 1 1 1 1 0 0 0 0 1 1 0 0 0 0 0 1 0 1 1 0 0 1 0
Vinx24y1 nx24y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 0 0 1 0 0 0 1 1 1 0 0 1 0 1 0 1 0 0 0 0 0 1 1 1 1 1 0
Vinx24y2 nx24y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 1 0 1 1 1 0 1 1 0 1 1 0 0 0 1 1 0 0 1 1 0 1 0 1 0 1 1
Vinx24y3 nx24y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 0 0 1 0 1 1 1 0 0 1 0 1 0 1 1 0 1 1 0 0 0 0 1 0 0 1 0
Vinx25y0 nx25y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 0 1 0 0 0 0 0 1 1 1 1 0 0 0 0 0 0 1 1 0 0 1 0 1 1 1 0 0
Vinx25y1 nx25y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 1 0 1 0 1 0 0 1 1 0 0 0 1 1 0 1 1 1 1 0 1 1 1 1 1 1 0
Vinx25y2 nx25y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 1 1 1 0 1 0 0 0 0 1 1 0 1 1 0 1 1 1 1 0 1 1 0 1 0 1
Vinx25y3 nx25y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 0 0 1 1 0 1 0 0 0 0 0 1 1 0 1 1 0 0 1 0 0 0 1 1 1
Vinx26y0 nx26y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 0 1 0 1 0 0 0 1 0 0 0 0 1 0 1 0 1 0 0 0 1 0 1 0 0 1
Vinx26y1 nx26y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 0 1 0 1 0 0 0 0 0 1 1 0 0 1 0 0 0 1 0 0 1 0 1 1 0 1 0
Vinx26y2 nx26y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 1 0 1 0 0 1 0 1 0 0 0 0 1 0 1 1 1 0 0 0 0 1 0 1 0 1
Vinx26y3 nx26y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 0 0 1 1 1 0 1 1 1 0 1 0 0 1 1 1 0 0 0 1 0 1 0 0 1 1
Vinx27y0 nx27y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 0 0 0 0 0 0 1 1 0 0 0 1 1 1 1 1 0 1 1 0 0 1 1 0 1 1 0
Vinx27y1 nx27y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 0 0 0 1 1 0 1 0 0 1 1 1 1 1 0 0 0 0 0 0 1 1 1 1 1
Vinx27y2 nx27y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 1 0 1 1 1 1 0 0 0 0 0 1 1 1 0 0 0 0 1 1 0 0 0 1 1 1 0
Vinx27y3 nx27y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 0 0 0 1 0 0 0 0 0 0 0 0 1 0 0 0 1 1 1 0 1 1 1 0 0 1 0 0
Vinx28y0 nx28y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 1 0 1 0 1 0 1 1 0 1 1 1 1 1 0 0 1 0 1 1 1 0 1 0 0 1
Vinx28y1 nx28y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 0 1 0 1 0 1 0 1 1 1 0 0 0 1 1 0 0 0 1 1 1 1 0 0 0 1
Vinx28y2 nx28y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 0 0 0 1 1 1 0 1 1 1 0 1 0 1 0 1 0 1 1 0 0 0 1 1 0 1
Vinx28y3 nx28y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 0 0 0 1 0 0 0 0 1 1 0 0 1 1 1 0 1 0 1 1 0 0 1 1 1 1 0 0
Vinx29y0 nx29y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 0 1 0 0 0 1 1 1 1 0 1 0 1 1 0 1 0 0 0 0 1 0 0 1 0 1 0
Vinx29y1 nx29y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 1 0 0 0 1 1 1 0 1 1 0 1 1 1 0 1 1 1 0 0 0 0 0 0 1 1 0 0 0
Vinx29y2 nx29y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 1 0 1 0 1 0 0 0 1 1 0 0 0 0 0 1 1 0 1 1 0 1 1 1 1 1 0
Vinx29y3 nx29y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 1 0 0 0 1 0 1 0 1 0 1 1 0 0 1 1 0 1 1 1 0 0 0 1 0 1
Vinx30y0 nx30y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 1 1 1 0 1 0 1 0 1 0 0 1 0 1 0 1 0 0 1 0 1 0 0 0 1
Vinx30y1 nx30y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 1 0 0 0 0 1 1 0 0 1 1 1 0 0 1 1 0 1 1 0 1 0 0 0 1 1 0 0 0
Vinx30y2 nx30y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0
*0 0 1 1 1 0 1 1 1 1 1 1 1 1 0 1 1 1 1 0 1 1 1 1 1 0 0 0 0 0
Vinx30y3 nx30y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 1 0 0 1 1 1 0 0 1 1 0 1 0 1 1 0 1 0 1 1 0 0 1 0 1 0 0
Vinx31y0 nx31y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 1 0 1 1 1 1 1 1 0 1 1 1 1 0 0 1 1 0 0 1 1 1 1 1 0 1
Vinx31y1 nx31y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 0 1 0 0 0 0 0 1 0 1 0 1 1 0 1 1 0 0 0 0 0 0 0 0 0 1
Vinx31y2 nx31y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 0 1 0 0 0 0 0 0 0 1 1 1 0 1 1 0 0 0 1 0 1 0 1 1 0 1 0 0 0
Vinx31y3 nx31y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 0 1 1 1 1 1 0 0 1 1 1 1 1 1 1 1 0 1 1 0 1 1 1 1 0 1 1 0
Vinx32y0 nx32y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 1 0 0 0 0 0 1 1 1 0 1 0 1 0 0 0 1 0 1 1 1 1 0 1 1
Vinx32y1 nx32y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 1 1 1 0 1 1 1 0 1 1 1 1 1 0 0 1 0 1 1 0 0 1 1 0 0 1
Vinx32y2 nx32y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 1 1 0 1 0 1 0 1 0 1 1 1 1 0 0 1 1 1 1 1 1 1 1 0 0 1 0
Vinx32y3 nx32y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 0 0 0 0 0 1 1 0 0 1 1 0 0 0 1 0 0 1 1 1 1 1 0 0 1
Vinx33y0 nx33y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 1 1 0 1 0 0 1 0 1 1 0 1 1 0 1 0 1 0 0 1 0 0 0 0 1
Vinx33y1 nx33y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 1 0 0 0 1 0 1 1 1 1 0 0 1 0 1 1 0 1 0 1 0 1 1 0 0 1
Vinx33y2 nx33y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 1 0 0 1 0 1 0 0 0 0 1 0 0 0 0 0 0 0 1 0 0 0 0 1 0 1 0
Vinx33y3 nx33y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 0 0 0 1 1 1 0 1 1 1 0 1 0 1 1 1 0 0 0 0 1 1 1 1 1
Vinx34y0 nx34y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 0 0 1 0 0 0 0 1 1 1 0 0 1 0 1 1 0 0 1 1 1 1 1 0 1 1
Vinx34y1 nx34y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 0 1 0 1 0 1 0 1 1 0 0 0 1 1 0 0 1 1 1 1 1 1 0 0 1 1
Vinx34y2 nx34y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 0 1 1 1 0 0 1 0 0 0 1 0 1 0 0 0 1 0 0 0 1 0 1 1 1 1
Vinx34y3 nx34y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 0 1 0 0 1 0 1 1 0 1 0 1 0 0 0 0 0 0 0 1 0 0 0 1 1 1 0 0
Vinx35y0 nx35y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 0 0 0 0 1 0 1 0 0 0 0 0 0 0 0 0 0 0 1 0 1 1 0 0 1 1
Vinx35y1 nx35y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 0 1 1 1 0 0 0 0 0 0 0 0 1 1 1 1 1 0 0 1 1 1 0 0 1 1
Vinx35y2 nx35y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0
*1 1 0 0 1 1 0 0 1 1 1 0 1 1 0 0 1 0 0 0 1 1 1 0 1 0 0 0 0 0
Vinx35y3 nx35y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 0 1 0 0 1 0 1 0 0 0 1 0 1 1 1 1 0 0 0 0 1 0 1 0 1 1
Vinx36y0 nx36y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 0 1 1 1 0 1 1 1 1 1 1 1 1 1 0 1 1 1 0 0 1 0 1 1 1 1 0
Vinx36y1 nx36y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 1 1 0 1 1 1 0 1 0 0 1 1 0 1 0 0 1 1 0 0 1 0 0 0 1 1 1
Vinx36y2 nx36y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 1 1 0 1 0 0 1 1 0 1 0 0 0 0 0 1 0 1 0 0 1 1 0 1 1 1 0 0
Vinx36y3 nx36y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 0 1 1 0 1 0 0 1 1 1 1 0 0 0 1 1 1 0 1 1 0 1 0 1 1
Vinx37y0 nx37y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 1 0 0 0 1 0 0 0 1 0 0 0 0 1 1 1 1 0 1 0 1 0 1 0 1 1
Vinx37y1 nx37y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 0 1 0 1 1 0 1 1 1 0 0 0 1 1 1 1 0 0 0 1 0 0 1 0 1 1 0
Vinx37y2 nx37y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 0 0 0 0 0 1 0 0 1 0 1 1 0 0 1 1 1 0 1 1 1 1 0 1 0 1 0
Vinx37y3 nx37y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 1 1 1 1 0 1 0 0 0 1 1 0 0 1 1 0 0 0 1 0 1 1 1 0 1 1 0 0
Vinx38y0 nx38y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 1 0 1 0 1 0 0 0 0 0 0 0 0 0 0 1 1 1 1 0 1 1 1 0 1 1 0 0
Vinx38y1 nx38y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 0 0 0 1 1 1 1 1 0 0 0 0 1 1 1 1 1 0 1 0 0 0 0 1 1 1 0
Vinx38y2 nx38y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 0 0 0 0 0 0 0 0 0 1 0 0 0 0 0 0 0 0 1 1 1 1 0 1 1 1 0
Vinx38y3 nx38y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 0 0 0 1 0 1 1 0 0 1 0 1 1 1 0 1 0 0 0 0 0 0 0 0 0 1
Vinx39y0 nx39y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 0 1 1 1 0 1 0 1 1 0 1 1 1 0 1 0 1 1 1 1 1 1 0 1 1
Vinx39y1 nx39y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 1 0 0 0 1 1 0 1 1 0 0 0 1 1 0 0 0 1 0 1 0 0 0 0 0 1
Vinx39y2 nx39y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 1 1 0 1 0 0 1 1 0 0 0 1 1 0 1 0 1 1 1 1 0 0 1 1 1 1
Vinx39y3 nx39y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 1 0 0 0 1 0 0 0 0 0 0 0 0 1 1 1 0 1 1 1 0 1 0 1 0 0 1
Vinx40y0 nx40y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 0 0 0 0 1 0 0 0 1 1 0 1 1 0 0 0 1 1 0 0 0 1 1 0 0 1
Vinx40y1 nx40y1 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 1 0 1 0 0 0 0 1 0 1 0 0 1 1 1 0 1 0 0 0 0 0 0 0 0 0 1
Vinx40y2 nx40y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 0 0 0 1 0 1 0 0 1 0 0 0 1 1 1 1 1 0 0 0 0 1 0 1 1 1 0
Vinx40y3 nx40y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 1 0 1 0 1 1 1 0 0 1 1 1 1 1 0 1 1 0 0 0 0 1 1 0 1 1 0
Vinx41y0 nx41y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 0 0 1 0 0 1 1 1 0 1 0 1 0 0 1 0 0 1 1 0 0 1 0 1 1 0
Vinx41y1 nx41y1 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 0 1 1 0 1 1 1 0 0 1 1 1 1 1 0 0 1 1 0 1 0 0 1 0 1 1 0 0
Vinx41y2 nx41y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 1 0 1 1 0 1 1 0 1 0 1 0 0 1 1 1 1 0 0 0 1 0 0 0 0 1 0 0
Vinx41y3 nx41y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 0 1 1 0 1 0 0 0 1 1 0 1 1 0 1 1 0 0 0 1 1 0 0 0 0 1
Vinx42y0 nx42y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 0 0 1 0 1 0 0 0 0 0 1 0 1 1 0 0 0 0 1 0 0 0 0 0 1 0
Vinx42y1 nx42y1 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 0 1 0 0 1 0 0 1 1 0 0 1 0 0 1 0 0 0 0 1 0 0 0 0 1 1 0 0
Vinx42y2 nx42y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 1 0 0 0 0 0 0 1 0 1 1 1 0 1 0 0 0 1 0 0 0 1 0 1 1 1 0 0 0
Vinx42y3 nx42y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 0 0 0 1 1 1 0 0 1 1 0 1 1 0 0 0 0 1 0 0 1 1 0 1 1 1 0
Vinx43y0 nx43y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 1 1 0 1 0 0 0 1 0 1 0 0 1 0 1 0 0 0 1 0 0 1 1 1 1 1 0 0
Vinx43y1 nx43y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 1 1 1 0 1 0 1 1 0 0 1 1 0 0 1 1 1 1 0 0 1 1 1 0 0 1
Vinx43y2 nx43y2 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 1 1 0 1 0 1 1 0 0 0 1 1 1 1 0 0 0 0 1 0 1 0 0 1 0 1 1
Vinx43y3 nx43y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 1 0 1 1 0 1 0 0 1 0 0 1 0 0 1 0 0 1 0 0 1 0 1 1 1 1
Vinx44y0 nx44y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 0 1 1 0 1 1 1 1 1 0 1 0 0 1 0 0 1 1 0 0 1 1 1 0 0 1
Vinx44y1 nx44y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 0 1 0 1 1 1 1 1 0 0 1 0 0 0 0 1 1 0 0 1 1 1 0 0 1 1
Vinx44y2 nx44y2 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 1 0 1 1 0 1 1 0 1 1 1 1 0 0 0 1 0 0 1 1 0 0 0 0 1 1
Vinx44y3 nx44y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 0 0 1 1 0 0 1 1 0 1 0 1 0 0 0 1 1 0 0 0 0 1 1 0 1 1 0
Vinx45y0 nx45y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 1 1 1 0 1 1 0 1 0 0 0 0 1 0 0 1 0 1 0 1 0 0 1 1 1 0 1
Vinx45y1 nx45y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 0 0 1 1 1 1 1 0 0 0 1 0 1 0 1 0 0 1 0 0 1 0 1 1 1 1 1 0
Vinx45y2 nx45y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 0 1 0 1 0 1 1 0 1 1 0 0 0 0 1 0 0 1 1 0 0 0 0 1 1 1 0
Vinx45y3 nx45y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 0 1 1 1 1 1 1 1 0 0 1 0 0 0 1 0 1 0 1 1 1 0 1 1 1 1 0 0
Vinx46y0 nx46y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 1 0 1 1 0 0 0 0 0 0 1 0 0 0 1 0 0 1 0 0 0 1 1 1 1 1
Vinx46y1 nx46y1 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 1 0 0 0 0 0 0 0 1 0 0 1 1 0 0 1 1 1 1 0 1 1 1 0 0 1
Vinx46y2 nx46y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 1 0 1 0 1 1 1 0 0 1 0 1 1 0 1 1 0 0 1 1 1 1 1 1 1 1
Vinx46y3 nx46y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 0 0 1 0 0 1 1 1 1 1 0 0 1 1 1 0 0 0 0 0 0 0 1 1 1 1
Vinx47y0 nx47y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 0 1 0 1 0 1 1 1 1 0 0 0 0 0 1 0 1 0 0 1 1 0 1 1 0 1
Vinx47y1 nx47y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 0 1 0 0 0 1 0 1 0 0 0 1 1 0 1 0 1 0 1 1 1 0 0 0 1 1 0
Vinx47y2 nx47y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 0 0 0 1 0 1 1 0 1 0 0 0 1 0 0 1 1 1 1 0 0 1 1 1 0 1 0 0
Vinx47y3 nx47y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 0 1 1 0 1 1 0 0 0 0 1 1 1 0 1 1 0 0 0 0 1 1 1 1 0 1 0 0
Vinx48y0 nx48y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 0 1 0 0 1 1 0 1 0 1 0 1 1 1 1 1 0 0 1 1 0 0 1 0 1 0
Vinx48y1 nx48y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 0 1 1 0 1 1 1 0 1 1 0 0 0 1 1 1 1 1 0 1 1 0 1 0 1 1
Vinx48y2 nx48y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 1 1 0 0 0 0 1 0 1 1 0 0 1 1 1 1 1 1 0 1 1 1 0 0 0 1
Vinx48y3 nx48y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 0 0 1 0 1 1 1 0 1 1 1 1 1 0 1 0 1 0 0 0 0 1 1 1 1
Vinx49y0 nx49y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 0 1 0 1 0 1 0 1 0 1 1 1 0 0 0 1 1 1 0 0 0 0 1 1 0 1 0 0
Vinx49y1 nx49y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*0 0 1 1 1 1 1 0 0 0 1 1 1 0 0 1 1 1 0 0 0 1 0 0 0 1 0 0 0 0
Vinx49y2 nx49y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 0 1 1 1 0 1 1 1 1 0 1 1 1 1 1 0 1 0 0 0 1 1 1 0 0 1 0
Vinx49y3 nx49y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 0 0 0 0 0 1 0 1 1 0 0 1 0 1 1 0 0 0 0 0 1 0 0 0 0 1 0
Vinx50y0 nx50y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 1 1 1 0 1 1 0 0 0 0 0 0 0 1 1 0 0 1 1 0 1 1 0 0 1 1 0 0
Vinx50y1 nx50y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 0 1 1 0 0 1 1 0 1 0 0 1 0 1 0 1 1 1 0 0 0 1 1 0 1 1
Vinx50y2 nx50y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0
*1 1 1 1 0 0 0 1 0 1 1 0 1 0 0 1 0 0 0 0 0 0 0 1 1 0 0 0 0 0
Vinx50y3 nx50y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*0 0 1 0 1 1 0 0 0 0 1 0 1 0 1 1 0 1 0 1 0 0 1 1 0 1 0 0 0 0
Vinx51y0 nx51y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 1 0 0 0 1 1 1 0 0 1 0 0 1 0 0 1 0 0 1 1 0 0 1 1 0 1 0
Vinx51y1 nx51y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 1 1 0 0 0 0 0 0 1 1 0 0 1 1 0 1 1 0 0 0 1 1 0 1 0 1 0
Vinx51y2 nx51y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 1 1 1 1 0 0 0 0 0 1 0 0 0 0 0 1 1 1 1 0 0 1 0 1 1 0
Vinx51y3 nx51y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0
*1 0 1 0 0 1 1 0 0 0 0 0 1 0 1 0 0 1 0 1 0 0 1 1 1 0 0 0 0 0
Vinx52y0 nx52y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 1 0 0 1 0 0 0 1 1 0 0 1 1 1 1 0 1 1 1 1 1 1 0 0 0 1
Vinx52y1 nx52y1 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 1 1 0 1 0 1 1 1 1 0 0 0 0 0 0 1 0 1 1 0 0 1 0 0 0 1 0
Vinx52y2 nx52y2 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 0 0 0 0 1 0 0 0 1 1 1 1 1 1 0 0 0 1 1 0 1 0 1 1 0 1 0 0 0
Vinx52y3 nx52y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 0 1 0 1 1 1 0 1 1 1 0 0 1 0 1 0 0 0 1 0 0 0 1 1 1 0
Vinx53y0 nx53y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 1 0 1 0 1 0 0 0 1 1 1 0 0 0 1 1 1 1 0 0 0 0 1 1 0 1 0
Vinx53y1 nx53y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 0 0 0 0 1 0 1 1 1 1 0 1 0 0 1 0 0 1 1 1 1 0 1 0 1 1 0
Vinx53y2 nx53y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 1 1 1 0 0 1 0 0 1 0 0 0 1 0 1 1 1 0 1 1 0 0 0 0 0 1 0
Vinx53y3 nx53y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 0 1 0 0 1 1 1 1 1 0 1 0 1 1 1 1 1 0 0 0 1 0 1 0 0 0 1 0
Vinx54y0 nx54y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 1 0 1 1 0 1 0 0 1 1 0 1 0 1 1 0 1 0 0 1 0 0 1 0 0 1 0 0 0
Vinx54y1 nx54y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 0 1 1 1 1 1 0 1 0 0 0 1 1 1 0 1 1 1 0 1 0 1 1 1 1 1 0 0 0
Vinx54y2 nx54y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 1 1 0 0 1 0 1 1 0 1 0 0 1 0 0 0 0 1 0 0 1 0 0 1 1 1 0
Vinx54y3 nx54y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 1 0 0 0 1 1 1 1 1 1 1 1 1 0 0 0 0 1 0 1 1 0 1 1 1 1 0 0
Vinx55y0 nx55y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 1 1 0 0 1 0 0 1 0 0 0 1 1 0 0 1 1 1 1 0 0 0 0 1 1 1 0 0 0
Vinx55y1 nx55y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 1 1 1 1 0 1 1 0 1 0 0 0 0 0 1 0 0 0 1 0 0 1 1 1 1 1
Vinx55y2 nx55y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 1 0 0 0 1 1 1 1 0 0 1 0 0 0 1 0 0 1 0 0 1 1 1 0 1 0
Vinx55y3 nx55y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 1 0 1 1 1 1 1 0 1 1 1 0 1 1 0 0 0 0 0 0 0 1 1 1 0 1
Vinx56y0 nx56y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 1 0 1 1 0 1 1 1 1 1 0 1 1 0 0 1 1 1 0 0 0 0 0 1 0 0 1
Vinx56y1 nx56y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 1 0 0 1 0 0 1 1 1 0 1 0 0 0 1 1 1 0 0 1 1 1 1 1 1 1 0
Vinx56y2 nx56y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 1 0 0 0 0 1 0 1 1 0 1 0 0 0 0 1 0 0 1 0 1 0 0 1 1 0 1
Vinx56y3 nx56y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 1 1 1 1 1 1 0 1 1 0 1 1 1 0 1 0 1 0 1 0 1 1 0 1 0 1
Vinx57y0 nx57y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 1 1 0 0 1 0 1 1 0 0 1 1 0 0 0 0 0 0 0 0 0 1 0 1 1 0
Vinx57y1 nx57y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 0 1 1 1 0 1 1 1 1 0 0 0 0 0 1 1 1 0 0 1 0 0 1 0 1 1 0
Vinx57y2 nx57y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 1 0 0 0 0 1 0 1 1 1 0 1 1 1 0 1 0 0 0 0 1 0 0 0 1 1 1
Vinx57y3 nx57y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 0 1 1 0 1 0 0 0 1 1 0 0 1 0 1 1 1 1 0 0 1 1 0 1 1 1
Vinx58y0 nx58y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 0 0 1 1 1 0 0 1 1 0 0 1 0 1 0 1 1 0 1 0 0 0 1 1 1 1 0
Vinx58y1 nx58y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 1 0 0 1 0 0 0 0 1 0 1 0 0 0 1 1 0 1 0 0 0 0 0 1 0 1 0 0 0
Vinx58y2 nx58y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 0 0 0 1 1 1 1 1 0 0 1 1 1 0 0 1 0 1 1 1 0 0 1 1 0 1
Vinx58y3 nx58y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 0 1 1 1 1 0 0 1 0 1 1 1 1 1 0 0 1 1 0 0 0 1 1 0 1
Vinx59y0 nx59y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 0 0 0 0 0 0 0 0 0 1 0 0 1 0 1 0 0 0 0 1 1 0 1 0 0 1
Vinx59y1 nx59y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 1 0 1 0 0 0 1 1 1 1 1 0 1 1 1 1 0 0 0 1 0 1 0 0 1 0 0
Vinx59y2 nx59y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 0 1 0 1 1 0 1 0 1 1 0 0 0 0 1 1 0 0 0 0 1 0 1 1 0 1 0 0 0
Vinx59y3 nx59y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 0 0 1 1 1 1 0 0 0 1 0 1 1 0 0 0 0 0 1 1 0 0 1 1 1 1
Vinx60y0 nx60y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 1 0 1 0 1 1 0 0 1 1 1 1 0 1 1 0 0 0 0 0 0 0 1 0 0 1 0
Vinx60y1 nx60y1 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 1 0 1 0 0 1 0 0 1 1 0 1 0 0 0 1 1 1 0 1 1 0 1 1 0 0 1
Vinx60y2 nx60y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 0 0 0 1 0 0 1 0 1 1 0 0 1 0 0 0 1 0 0 1 1 1 0 0 0 1 0
Vinx60y3 nx60y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 0 0 1 0 0 1 0 0 1 0 0 1 1 0 1 1 1 0 1 1 0 1 0 1 0 1
Vinx61y0 nx61y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 0 0 1 0 1 0 1 0 1 1 0 0 1 0 1 0 1 1 0 1 1 1 1 0 0 1 0 0 0
Vinx61y1 nx61y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 1 0 0 1 1 0 0 1 1 1 0 0 0 1 1 0 0 1 1 1 0 0 1 0 0 1 0 0
Vinx61y2 nx61y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 1 0 0 1 1 0 1 0 0 1 0 0 0 1 0 1 0 0 0 0 1 1 0 0 0 1
Vinx61y3 nx61y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*0 0 1 1 0 0 1 1 0 1 0 0 1 1 1 0 0 1 0 0 1 1 1 0 0 1 0 0 0 0
Vinx62y0 nx62y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 1 1 0 0 0 0 1 1 0 0 1 0 0 0 1 1 1 0 0 0 1 1 0 0 1 1 0
Vinx62y1 nx62y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 1 0 1 0 1 0 0 1 1 0 1 1 1 1 0 1 1 0 1 1 1 1 0 1 0 1 0 0 0
Vinx62y2 nx62y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 1 1 0 0 0 0 0 0 1 0 0 0 1 1 1 0 0 0 0 1 1 0 1 0 1 0 0
Vinx62y3 nx62y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 0 0 1 0 1 0 1 0 0 1 1 0 1 0 1 0 0 1 0 1 0 1 0 1 0 1
Vinx63y0 nx63y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 0 0 0 0 1 0 1 1 0 1 0 0 1 1 0 0 0 0 0 1 0 0 0 1 1 1 0
Vinx63y1 nx63y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 1 0 0 0 1 0 0 0 0 1 0 0 1 1 1 0 0 1 1 0 1 1 1 1 1 0 1
Vinx63y2 nx63y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 0 1 1 0 1 1 0 0 1 0 0 1 0 0 0 1 0 0 0 1 1 1 1 0 0 1
Vinx63y3 nx63y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 0 0 1 1 0 0 0 0 0 0 0 1 1 1 0 0 1 1 1 0 1 0 0 1 0 1
Vinx64y0 nx64y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 1 0 0 0 1 1 0 1 0 1 1 1 0 1 0 1 1 0 1 0 1 1 0 1 1
Vinx64y1 nx64y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 0 1 1 0 1 0 1 0 1 1 1 1 0 0 0 1 1 1 1 1 1 0 1 1 0 1 0 0
Vinx64y2 nx64y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 1 0 1 1 1 0 0 0 0 0 0 1 1 1 0 1 1 0 1 1 1 0 1 0 0 1
Vinx64y3 nx64y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 0 1 0 0 1 1 0 0 0 1 1 0 0 0 0 0 1 1 0 0 1 0 1 1 0 1 0
Vinx65y0 nx65y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 0 1 0 0 0 1 0 1 1 1 0 1 1 1 1 1 0 0 1 1 1 0 1 0 1 1
Vinx65y1 nx65y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 1 0 0 0 0 0 1 1 1 0 0 0 1 0 1 0 0 1 1 0 0 1 0 1 1 1 0
Vinx65y2 nx65y2 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 0 1 0 0 0 1 0 0 0 0 1 0 1 1 0 0 0 0 1 0 0 1 1 0 0 1 0
Vinx65y3 nx65y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 0 0 0 1 1 0 0 1 1 0 1 1 1 0 1 1 0 1 1 0 0 1 1 1 1 1
Vinx66y0 nx66y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 1 1 1 0 1 0 1 1 0 0 0 1 0 1 1 1 0 1 0 0 1 1 1 0 0 1 1
Vinx66y1 nx66y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 0 1 0 1 0 1 1 1 1 1 1 1 1 0 0 0 1 1 0 1 1 0 0 1 1 1 0
Vinx66y2 nx66y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 1 0 0 1 1 1 1 0 0 1 1 1 1 1 1 1 0 1 1 1 1 0 0 1 0 1 0
Vinx66y3 nx66y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 0 0 1 0 1 0 1 1 1 1 1 0 0 1 0 1 0 0 1 0 1 1 1 1 1 1
Vinx67y0 nx67y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 0 1 1 1 1 0 1 0 1 0 1 1 1 0 0 0 0 1 0 0 1 1 0 0 1 1
Vinx67y1 nx67y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 0 1 0 0 0 1 0 0 0 0 1 1 0 0 0 1 1 0 1 0 1 1 0 0 1 0
Vinx67y2 nx67y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 0 0 0 1 1 0 0 1 0 1 1 0 1 0 0 0 0 1 0 1 1 1 0 0 0 1 0 0
Vinx67y3 nx67y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 0 0 0 0 1 1 0 0 0 0 0 1 0 0 0 0 0 1 1 0 1 1 1 0 1 1
Vinx68y0 nx68y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*0 0 1 1 0 0 0 0 1 0 1 1 1 0 1 1 1 0 0 1 1 0 0 0 0 1 0 0 0 0
Vinx68y1 nx68y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 0 1 0 1 0 1 1 0 1 1 0 0 0 0 1 0 0 0 1 1 0 0 1 1 1 1
Vinx68y2 nx68y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 0 1 0 1 0 1 1 1 0 0 1 0 1 0 0 1 0 0 1 1 1 1 1 1 1 0 0
Vinx68y3 nx68y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 0 0 1 1 1 0 0 1 0 1 0 1 1 0 1 1 1 0 0 0 1 0 0 0 0 1
Vinx69y0 nx69y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 0 0 1 0 1 1 0 1 0 1 0 0 1 0 0 1 1 1 1 1 0 0 0 0 0 1
Vinx69y1 nx69y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 1 0 0 0 1 0 0 1 1 0 1 1 0 0 1 1 0 1 0 0 1 1 1 0 1 1 0 0
Vinx69y2 nx69y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 1 1 1 0 0 1 1 0 1 1 0 1 1 0 1 0 0 0 1 0 1 0 1 0 1 1 0 0
Vinx69y3 nx69y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 0 0 0 0 1 0 1 1 1 0 1 0 0 0 1 1 1 0 0 0 0 1 0 1 1 1
Vinx70y0 nx70y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 0 0 1 0 0 1 1 0 1 1 1 1 0 1 0 0 0 1 1 0 0 1 1 0 0 1 0
Vinx70y1 nx70y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 1 0 0 0 1 1 0 0 1 1 0 1 0 0 0 0 0 1 1 0 0 1 1 1 0 1
Vinx70y2 nx70y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 1 1 1 0 1 1 0 0 0 1 1 1 1 0 1 0 1 0 1 1 0 1 1 0 1 1
Vinx70y3 nx70y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0
*1 1 1 0 1 1 0 0 1 0 0 0 1 1 0 1 0 1 0 1 1 0 1 0 1 0 0 0 0 0
Vinx71y0 nx71y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 1 0 1 0 1 1 1 0 0 0 0 1 1 0 1 0 1 1 1 1 0 0 0 1 1 1 0 0
Vinx71y1 nx71y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 1 0 1 1 0 1 0 1 1 1 0 0 1 1 1 1 0 1 1 1 1 1 0 0 1 0
Vinx71y2 nx71y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 1 0 1 1 0 0 1 1 0 1 0 1 1 0 0 0 0 1 1 1 1 0 0 1 1 1 0 0 0
Vinx71y3 nx71y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 1 0 0 0 0 1 0 1 1 1 0 0 0 0 1 0 1 0 0 1 0 1 1 1 0 1 0
Vinx72y0 nx72y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 1 1 1 1 0 1 1 0 1 0 1 1 1 1 1 0 1 0 1 1 1 1 1 0 1 1
Vinx72y1 nx72y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 1 0 1 0 0 0 1 1 1 1 0 1 0 0 0 0 1 1 0 1 1 0 1 0 0 1
Vinx72y2 nx72y2 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 0 1 1 0 1 0 0 0 1 1 1 0 0 1 1 1 1 0 0 1 0 0 1 0 0 1
Vinx72y3 nx72y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 1 1 0 1 0 1 1 0 0 1 0 0 1 0 0 0 0 1 0 1 1 1 0 1 1 1 0 0
Vinx73y0 nx73y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0
*1 0 0 0 1 1 1 1 0 0 1 1 1 0 0 0 0 0 1 1 1 1 0 0 0 0 0 0 0 0
Vinx73y1 nx73y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 1 1 1 1 1 0 1 1 1 0 1 0 0 0 1 1 0 1 1 0 0 0 0 1 1 1
Vinx73y2 nx73y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 1 0 1 0 1 0 0 1 0 1 0 0 1 0 0 1 1 1 1 1 0 1 0 1 0 1 0 0
Vinx73y3 nx73y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 0 0 1 1 1 0 1 0 0 1 1 1 1 1 0 0 0 0 1 0 1 1 1 1 1
Vinx74y0 nx74y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 1 1 0 1 1 0 1 1 0 0 1 0 0 0 0 1 0 1 0 0 1 1 0 0 1 1
Vinx74y1 nx74y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0
*0 1 1 1 0 1 1 0 1 0 1 0 0 0 1 0 1 1 1 0 0 0 0 0 0 0 0 0 0 0
Vinx74y2 nx74y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 0 0 0 0 1 0 0 0 0 1 1 0 1 0 0 0 1 1 0 1 0 0 0 1 1
Vinx74y3 nx74y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 0 0 1 1 0 0 1 0 1 1 1 0 1 1 1 1 0 1 0 0 0 1 1 0 1 1
Vinx75y0 nx75y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 0 0 1 1 0 0 0 0 0 0 1 0 1 1 1 0 1 1 1 1 1 0 1 1 1 1 0 0
Vinx75y1 nx75y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 0 0 1 1 1 1 0 0 0 0 1 0 1 1 0 0 0 1 0 1 0 0 0 0 1 1
Vinx75y2 nx75y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 0 0 1 1 1 0 0 1 0 1 0 1 0 1 1 0 1 1 1 1 1 1 1 1 1 1 0
Vinx75y3 nx75y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 0 1 1 0 0 1 1 0 1 1 0 0 0 1 1 1 1 1 1 1 0 1 1 1 0 1 0 0
Vinx76y0 nx76y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 1 1 1 1 0 1 1 0 0 1 0 0 1 1 1 1 0 1 0 0 0 1 0 1 1
Vinx76y1 nx76y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 1 0 1 1 0 0 0 1 1 0 0 1 0 0 0 1 1 0 0 0 0 0 1 0 0 1 0 0
Vinx76y2 nx76y2 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 0 1 0 1 0 0 1 1 1 1 0 0 0 0 1 1 0 0 1 1 0 0 1 1 1 1 0 0
Vinx76y3 nx76y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 1 0 1 0 0 0 1 0 1 0 1 1 0 0 1 0 0 0 1 1 0 1 0 1 1 1 0 0 0
Vinx77y0 nx77y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*0 0 0 1 1 1 1 0 0 1 0 0 1 1 1 1 0 1 1 0 0 0 0 0 1 1 0 0 0 0
Vinx77y1 nx77y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 1 1 0 1 0 0 0 0 0 0 0 1 0 1 1 1 0 1 0 0 0 1 0 0 1 1 0
Vinx77y2 nx77y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 0 1 0 1 0 0 1 1 0 0 0 0 1 0 0 0 0 0 1 0 0 1 0 1 1 1 0 0
Vinx77y3 nx77y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 0 0 1 0 1 0 1 0 1 1 1 1 0 1 1 0 1 1 1 0 0 1 0 0 1 1 1 0
Vinx78y0 nx78y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 0 1 0 0 1 0 0 0 1 0 1 0 0 1 1 1 1 0 0 0 0 1 0 1 1 1
Vinx78y1 nx78y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 0 1 1 1 1 1 0 0 1 0 0 1 1 1 0 0 0 1 1 0 1 0 0 1 1
Vinx78y2 nx78y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*1 0 1 0 1 0 1 1 0 1 0 0 0 1 1 0 0 1 1 0 0 1 1 1 0 1 0 0 0 0
Vinx78y3 nx78y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 1 0 1 0 1 0 1 0 0 1 1 0 1 0 0 0 1 1 0 1 1 1 1 0 1 1
Vinx79y0 nx79y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 0 0 0 0 1 1 0 1 1 1 0 0 0 0 1 1 1 1 1 0 0 0 1 1 0 1
Vinx79y1 nx79y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 1 0 1 0 1 0 1 0 0 0 0 0 0 0 1 1 0 1 0 1 1 0 1 0 0 1 0
Vinx79y2 nx79y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 0 0 1 0 1 0 0 0 0 1 1 0 0 0 1 1 0 0 1 1 0 1 0 0 1 0
Vinx79y3 nx79y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 1 0 1 0 0 0 1 1 0 1 0 1 1 1 0 1 1 1 0 0 0 0 0 0 0 1
Vinx80y0 nx80y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 0 0 0 0 1 1 1 0 1 1 0 0 1 0 1 0 1 1 0 0 0 1 0 0 1 1
Vinx80y1 nx80y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 0 0 1 0 0 1 1 1 1 0 0 0 1 1 1 1 0 0 1 0 1 1 1 1 1 0
Vinx80y2 nx80y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 1 0 0 0 0 0 0 1 1 0 1 0 0 1 1 0 1 0 1 1 0 1 0 0 1 1
Vinx80y3 nx80y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*1 1 0 0 0 0 0 1 1 0 1 1 1 0 1 0 1 0 1 0 1 1 1 1 1 1 0 0 0 0
Vinx81y0 nx81y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 0 0 0 1 0 1 0 0 0 0 1 0 0 0 1 0 1 0 0 1 0 1 1 1 0 1 1 0
Vinx81y1 nx81y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 0 1 1 1 1 0 0 1 0 1 1 1 1 1 1 0 1 0 1 0 1 1 1 0 0 1
Vinx81y2 nx81y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 0 0 1 0 0 0 0 0 0 1 1 1 0 1 0 1 0 1 0 1 1 0 0 0 1 1
Vinx81y3 nx81y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 1 1 0 1 0 0 0 0 0 0 1 1 0 1 0 1 1 1 1 1 1 1 0 1 1 1 0 0
Vinx82y0 nx82y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 1 1 0 1 1 0 0 1 0 1 1 0 1 0 0 0 1 0 0 0 1 0 0 0 1 0 0
Vinx82y1 nx82y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 1 1 0 0 0 0 1 0 1 1 0 1 1 1 1 1 1 1 1 1 1 1 0 1 0 1
Vinx82y2 nx82y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 1 1 0 0 0 0 1 1 0 1 0 1 0 0 1 0 0 1 1 0 1 1 0 1 1 1
Vinx82y3 nx82y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 0 0 1 0 1 1 0 0 1 1 0 0 1 1 0 1 0 1 0 1 0 1 0 0 0 1 0
Vinx83y0 nx83y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 0 1 1 1 1 0 0 1 1 0 1 0 1 0 0 0 1 1 0 1 0 0 1 1 1 0 1 0
Vinx83y1 nx83y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 1 1 1 0 1 1 1 1 1 1 1 1 0 1 0 1 0 0 0 0 1 1 1 0 1 0 0
Vinx83y2 nx83y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*1 0 1 1 1 1 1 1 0 0 1 1 0 1 1 0 0 0 1 0 1 0 1 0 0 1 0 0 0 0
Vinx83y3 nx83y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 1 0 1 0 1 0 1 1 1 0 1 1 1 0 1 0 0 0 1 1 0 0 0 0 1 1
Vinx84y0 nx84y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 1 0 1 0 1 1 1 1 0 0 1 0 0 1 0 0 0 1 0 0 1 0 0 0 0 1 0
Vinx84y1 nx84y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 0 1 0 1 1 1 1 0 0 0 1 1 0 0 0 1 1 0 0 0 0 1 0 0 1 1
Vinx84y2 nx84y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 0 0 1 0 1 0 1 1 1 1 1 1 0 1 1 0 1 0 0 0 0 0 1 1 1 0
Vinx84y3 nx84y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 1 0 1 0 0 1 0 0 0 0 0 0 1 1 1 0 0 0 0 0 1 1 1 0 1 1 0
Vinx85y0 nx85y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 1 1 1 0 1 1 1 0 1 0 1 0 0 0 0 1 0 1 1 0 0 0 0 1 0 0 1
Vinx85y1 nx85y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 1 0 0 1 0 0 1 1 0 1 0 1 0 1 1 0 0 0 0 0 0 1 1 0 0 1
Vinx85y2 nx85y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 1 1 0 1 1 0 1 1 1 1 0 1 0 0 1 0 1 0 0 0 0 1 1 1 1 1
Vinx85y3 nx85y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 1 1 0 0 0 1 0 0 1 0 1 0 1 1 0 1 0 0 1 1 1 0 1 1 0 1 0
Vinx86y0 nx86y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 1 1 1 0 0 0 0 0 0 1 1 0 1 0 1 1 0 1 1 1 0 0 0 1 0 1 0
Vinx86y1 nx86y1 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 0 1 1 1 0 0 1 0 1 0 1 1 1 0 1 0 0 1 1 1 0 1 0 0 1 1 0
Vinx86y2 nx86y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 1 1 1 1 1 1 1 0 1 1 0 1 0 0 1 1 0 0 0 0 1 0 1 0 1 0 1
Vinx86y3 nx86y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 0 0 1 1 0 0 0 1 1 1 0 0 0 0 1 1 1 1 0 0 1 1 1 1 1 1
Vinx87y0 nx87y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 0 0 1 0 1 1 1 0 0 0 1 1 0 1 1 0 1 0 1 0 1 1 0 0 0 1 0 0 0
Vinx87y1 nx87y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 0 1 1 0 0 0 1 0 0 1 1 0 0 1 1 1 0 1 0 0 0 1 1 1 1
Vinx87y2 nx87y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 0 0 1 0 1 0 1 0 0 0 0 0 1 1 0 1 0 1 0 1 1 1 1 0 0 1
Vinx87y3 nx87y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 1 0 0 1 1 1 1 0 0 1 0 0 1 0 1 1 0 1 0 0 1 1 0 0 1 1 0
Vinx88y0 nx88y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 1 0 0 0 1 1 1 0 1 0 1 0 1 1 1 1 0 1 1 1 0 1 1 1 0 1 0 0 0
Vinx88y1 nx88y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 0 0 1 0 1 0 1 1 1 1 0 1 1 0 0 0 0 1 0 0 0 1 1 1 0 1 0
Vinx88y2 nx88y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 0 1 0 1 1 1 0 1 0 1 1 1 1 1 1 1 1 0 1 0 1 0 0 1 1 0 0
Vinx88y3 nx88y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 1 0 0 1 0 0 0 0 1 0 0 0 0 0 0 1 1 1 1 0 0 1 0 1 0 1
Vinx89y0 nx89y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 1 1 1 1 0 1 1 0 1 1 1 1 1 0 0 0 1 1 1 1 0 1 0 0 0 1
Vinx89y1 nx89y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 0 0 1 1 1 1 0 0 0 0 0 0 0 0 1 1 0 0 0 0 0 1 1 0 1 0
Vinx89y2 nx89y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 1 0 1 1 0 1 0 1 1 1 1 1 1 0 0 0 0 0 0 1 1 0 0 1 1 0 1 0
Vinx89y3 nx89y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 1 0 1 1 0 0 1 0 0 0 1 1 1 0 0 0 0 0 1 0 0 1 0 0 1 1 0 0
Vinx90y0 nx90y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 1 1 1 0 0 0 0 0 1 0 1 0 1 1 0 0 0 1 1 0 1 0 1 0 0 1
Vinx90y1 nx90y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 0 1 1 0 0 0 1 1 1 0 1 0 0 1 0 1 0 0 0 1 0 1 1 0 0 1 0
Vinx90y2 nx90y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 0 1 1 1 1 0 1 1 0 1 1 0 0 1 0 1 0 1 1 1 1 0 0 1 1 1 0
Vinx90y3 nx90y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 0 1 1 0 1 1 1 1 0 0 0 1 0 1 1 1 1 1 1 0 1 0 0 1 1 1 0 0 0
Vinx91y0 nx91y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 1 0 0 1 1 0 1 1 1 0 1 1 0 0 0 1 0 1 1 0 1 1 1 1 1 1
Vinx91y1 nx91y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 0 1 1 0 0 0 1 1 0 1 0 0 0 0 0 1 0 0 0 1 1 1 0 0 1 1
Vinx91y2 nx91y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 1 0 1 0 1 0 0 1 0 1 1 0 0 1 1 1 1 0 0 1 1 0 1 0 0 1 0 0 0
Vinx91y3 nx91y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 0 0 0 1 1 0 1 1 0 1 1 1 1 1 1 1 1 0 1 0 1 0 0 0 0 1 0
Vinx92y0 nx92y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 1 1 1 0 0 0 1 0 1 0 0 0 1 0 0 0 1 0 1 1 0 1 0 1 0 1
Vinx92y1 nx92y1 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 0 1 1 1 1 1 0 0 0 0 0 0 0 0 0 0 1 1 0 0 1 0 1 0 0 1 0
Vinx92y2 nx92y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 0 1 0 0 0 1 0 0 0 1 0 1 0 0 0 1 0 0 1 1 1 0 0 1 0 1 0
Vinx92y3 nx92y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 1 1 0 1 1 0 0 0 0 1 1 0 1 1 1 0 1 1 1 0 1 0 0 0 1 1
Vinx93y0 nx93y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 1 1 0 1 0 1 0 0 0 0 1 0 0 0 0 0 1 1 1 0 0 0 0 0 0 1
Vinx93y1 nx93y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 0 0 1 1 1 1 0 1 0 1 0 1 1 1 1 0 0 0 1 1 0 0 0 1 1 1 0 0
Vinx93y2 nx93y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 1 0 1 1 1 1 1 0 0 1 0 0 0 1 1 0 1 1 0 0 0 1 0 1 0 1 0 0
Vinx93y3 nx93y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 0 1 1 0 0 0 1 1 1 0 1 0 0 1 0 1 0 0 1 1 1 0 0 0 0 1
Vinx94y0 nx94y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 0 0 0 1 0 1 0 0 0 1 0 0 0 1 1 1 1 0 0 0 1 0 0 1 0 1 0
Vinx94y1 nx94y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 1 0 1 0 0 0 0 1 1 1 1 1 1 1 0 1 1 1 0 0 1 0 1 1 0 1 1 0
Vinx94y2 nx94y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 1 0 1 1 1 1 0 0 0 1 1 0 1 1 1 0 1 1 1 0 1 1 0 1 0 1
Vinx94y3 nx94y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 0 0 1 1 1 1 0 0 0 1 1 1 1 1 0 1 0 0 0 1 0 1 1 1 1
Vinx95y0 nx95y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 1 1 0 1 0 1 1 1 0 1 0 1 1 1 0 0 0 0 0 1 1 1 0 0 0 1 0
Vinx95y1 nx95y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 0 0 1 0 0 0 0 1 0 0 1 0 1 0 0 0 1 0 0 1 1 0 1 0 1 1 1 0
Vinx95y2 nx95y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 1 0 0 0 0 1 0 1 0 1 0 1 1 0 1 0 1 1 0 1 1 0 1 1 1 1 0
Vinx95y3 nx95y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 0 1 0 1 1 1 1 1 1 0 0 0 0 0 0 1 1 0 0 0 1 1 1 0 1 1 0 0 0
Vinx96y0 nx96y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 0 1 1 1 0 0 1 1 0 0 0 0 1 1 1 1 0 0 1 0 0 0 0 0 0 1
Vinx96y1 nx96y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 1 0 1 1 0 0 0 0 0 0 1 1 1 1 1 0 1 0 0 1 0 0 1 1 1 1
Vinx96y2 nx96y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 1 1 1 0 0 1 0 0 0 1 1 0 1 0 0 1 0 1 0 0 0 1 0 1 0 1 0
Vinx96y3 nx96y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 1 1 0 1 1 1 1 0 1 1 1 0 0 1 1 1 1 1 0 0 1 0 0 1 1 1 1
Vinx97y0 nx97y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 1 1 0 0 0 1 0 0 1 0 1 0 1 1 1 1 0 0 0 0 0 0 0 0 1 1
Vinx97y1 nx97y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 1 1 0 1 0 1 0 0 0 0 0 0 1 0 1 0 0 1 0 0 0 1 0 0 1 1 0
Vinx97y2 nx97y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 1 1 0 0 1 0 0 1 0 1 0 0 1 0 0 1 1 1 1 1 0 1 1 0 1 0
Vinx97y3 nx97y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 0 0 0 0 0 1 0 1 0 1 1 0 0 1 1 0 0 0 1 1 1 0 1 0 1
Vinx98y0 nx98y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 1 0 1 0 0 0 0 0 0 0 0 0 0 0 1 1 1 0 0 1 0 0 1 0 0 0 1
Vinx98y1 nx98y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 1 1 0 0 1 0 0 1 1 1 1 0 0 0 1 1 0 1 0 1 1 1 1 0 0 1 0 0
Vinx98y2 nx98y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0
*0 1 0 1 0 1 1 0 0 1 0 1 0 0 1 0 1 0 0 1 1 0 0 0 0 0 0 0 0 0
Vinx98y3 nx98y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 1 1 0 1 0 0 0 1 0 0 1 0 1 0 1 0 0 0 1 1 1 1 0 0 1
Vinx99y0 nx99y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 0 0 1 0 1 1 1 0 1 0 1 1 1 0 0 1 0 1 1 1 0 0 1 1 0 1 0 0
Vinx99y1 nx99y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 0 0 0 0 0 1 0 0 0 0 0 0 0 0 1 0 1 1 0 0 0 1 0 0 0 1
Vinx99y2 nx99y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 0 0 0 1 1 0 0 1 1 0 0 0 1 0 1 0 1 1 1 1 1 1 1 1 1 0
Vinx99y3 nx99y3 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 1 1 1 0 0 0 0 1 1 0 1 0 1 0 0 0 1 0 0 1 0 0 1 0 1 1 0
Vinx100y0 nx100y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 0 0 0 0 1 0 1 0 1 1 1 0 1 0 0 0 1 1 0 0 0 0 0 0 0 1
Vinx100y1 nx100y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 1 1 0 1 1 0 0 1 0 0 0 0 0 0 1 1 0 1 1 0 0 1 0 0 1 0
Vinx100y2 nx100y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 1 1 0 0 1 1 0 1 1 1 1 0 0 1 1 1 0 1 0 1 0 1 0 0 0 1
Vinx100y3 nx100y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 0 0 1 0 0 1 1 0 1 0 0 1 0 0 0 0 0 0 1 0 0 0 1 0 1 0 0
Vinx101y0 nx101y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 0 0 0 0 1 1 0 1 0 1 1 0 1 1 1 1 1 1 1 0 0 0 1 0 1 1 0 0
Vinx101y1 nx101y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 1 0 1 1 0 1 1 1 0 0 0 1 0 0 1 0 1 1 0 0 0 1 1 0 1
Vinx101y2 nx101y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 1 0 0 1 0 0 1 0 0 0 1 0 1 0 1 1 1 0 0 1 0 1 1 1 1 1
Vinx101y3 nx101y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 0 1 0 0 1 1 0 1 1 1 0 1 1 1 1 1 1 0 1 0 1 1 1 0 1 1
Vinx102y0 nx102y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 0 1 0 0 1 1 1 0 1 1 1 0 0 1 1 0 0 1 0 0 1 1 0 1 0 1
Vinx102y1 nx102y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 0 1 0 1 0 1 0 1 1 1 0 1 1 1 1 1 0 0 0 0 1 1 0 1 1 1 1
Vinx102y2 nx102y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 1 0 0 0 1 0 1 1 1 0 0 0 0 0 1 0 1 1 1 0 0 0 1 0 1 1
Vinx102y3 nx102y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 0 1 0 0 1 0 0 1 0 0 0 0 0 1 1 1 1 1 1 0 0 0 0 0 1 1
Vinx103y0 nx103y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 1 1 0 0 0 0 0 0 0 1 0 0 1 0 0 1 1 0 0 0 0 1 1 0 1
Vinx103y1 nx103y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 0 0 1 0 1 1 0 0 1 0 0 1 0 0 1 0 0 1 1 0 1 1 0 0 0 1 0 0
Vinx103y2 nx103y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 1 0 0 0 1 0 0 0 1 0 1 0 1 0 1 1 1 0 0 1 0 1 0 1 1 1
Vinx103y3 nx103y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 0 1 1 0 1 1 0 0 0 1 1 1 0 1 1 0 0 1 0 0 0 0 1 1 0 1
Vinx104y0 nx104y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 1 0 1 0 0 0 1 0 1 0 1 1 0 0 1 1 0 1 0 1 0 0 0 0 0 1
Vinx104y1 nx104y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 0 1 0 0 1 1 1 0 1 1 0 1 1 1 1 0 0 1 1 0 1 1 0 0 1 1
Vinx104y2 nx104y2 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 1 1 0 0 1 1 0 1 0 0 0 1 1 1 0 0 0 0 1 1 1 1 1 0 0 1
Vinx104y3 nx104y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 0 0 1 0 0 1 1 1 1 1 1 0 1 0 1 1 0 1 1 1 1 1 0 1 1 1 1 0
Vinx105y0 nx105y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 1 0 1 0 1 0 0 1 0 0 1 1 1 1 0 0 0 1 0 1 0 1 1 0 0 1 1
Vinx105y1 nx105y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0
*1 0 0 1 1 1 0 0 0 1 1 0 0 0 0 0 0 0 1 1 1 1 0 0 0 0 0 0 0 0
Vinx105y2 nx105y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0
*0 1 0 0 1 1 1 0 0 0 0 0 0 0 0 0 0 1 1 0 1 0 1 0 1 1 0 0 0 0
Vinx105y3 nx105y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 0 1 1 0 0 0 0 1 1 0 1 0 0 0 0 1 1 0 1 0 0 0 0 1 1 1 0 0
Vinx106y0 nx106y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 1 0 0 1 1 1 0 1 1 0 0 1 1 0 1 0 0 1 1 1 1 0 1 1 1 1 0
Vinx106y1 nx106y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 0 1 1 0 0 0 1 1 1 0 1 1 1 0 0 1 1 0 1 1 1 1 1 0 1 0 1 0
Vinx106y2 nx106y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 0 1 0 1 1 0 0 1 1 0 1 0 0 0 0 0 1 1 1 1 0 1 0 1 1 0
Vinx106y3 nx106y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 0 0 0 0 0 0 0 1 1 0 1 0 0 0 0 0 1 0 0 1 0 0 1 1 0 1
Vinx107y0 nx107y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 1 0 1 1 1 0 0 1 1 0 1 0 1 1 0 1 0 0 1 1 1 1 0 1 0 1
Vinx107y1 nx107y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 0 1 1 1 0 1 1 0 0 1 0 0 1 0 1 0 1 0 0 1 0 0 1 0 1
Vinx107y2 nx107y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 1 1 0 0 1 0 0 0 0 0 0 0 0 0 1 1 1 0 0 0 0 0 1 1 1 1 0 0
Vinx107y3 nx107y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 0 1 1 1 0 0 1 0 1 1 1 1 0 1 0 0 1 1 0 1 0 0 1 1 0 1 0
Vinx108y0 nx108y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 1 0 1 0 1 1 1 1 0 0 1 0 1 1 1 0 0 0 1 1 1 0 1 0 1 0 1
Vinx108y1 nx108y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 0 1 0 1 1 0 1 0 1 0 1 1 1 0 0 1 1 0 1 1 1 0 1 1 0 1 0
Vinx108y2 nx108y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 0 0 0 0 0 0 1 0 0 0 1 1 1 1 0 0 1 1 1 1 0 0 0 0 1 1
Vinx108y3 nx108y3 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 1 1 1 0 0 1 0 1 0 1 1 1 1 1 0 0 1 0 1 0 1 1 0 1 1 1 1
Vinx109y0 nx109y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 1 0 0 1 1 0 1 1 1 1 0 0 0 1 0 1 1 0 0 1 0 1 0 1 0 1 1
Vinx109y1 nx109y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 0 0 1 1 1 0 0 0 1 0 0 1 0 1 1 1 0 1 0 0 0 0 0 1 0 1 0 0
Vinx109y2 nx109y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 0 1 1 0 1 0 1 1 1 1 1 0 1 1 0 0 0 1 0 1 0 0 1 1 1 0 1 0 0
Vinx109y3 nx109y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 0 1 1 0 1 1 1 1 1 1 1 0 1 1 0 0 0 1 1 1 0 1 0 1 1 1
Vinx110y0 nx110y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 1 0 0 1 0 1 0 0 0 0 0 0 0 1 0 0 0 0 0 0 0 0 1 0 1 1 0 0
Vinx110y1 nx110y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 1 1 1 0 0 1 0 0 1 0 0 1 0 0 0 0 1 1 0 1 0 0 0 0 0 1
Vinx110y2 nx110y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 1 0 0 0 0 1 0 0 1 1 0 0 1 0 1 0 1 1 0 1 0 1 1 1 0 1 0 0
Vinx110y3 nx110y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 0 0 1 1 0 1 1 0 0 0 0 0 1 1 0 0 1 0 0 1 1 0 0 0 0 1 0 0 0
Vinx111y0 nx111y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 1 1 0 1 1 1 1 1 0 0 1 1 0 0 0 0 0 1 1 1 1 1 0 1 1 0 1 0
Vinx111y1 nx111y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 1 0 1 1 1 1 0 0 1 0 1 0 0 0 0 1 1 0 0 0 0 0 1 0 1 0
Vinx111y2 nx111y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 1 0 1 0 1 1 1 0 0 0 0 0 0 1 1 1 0 1 0 0 1 0 1 1 0 1
Vinx111y3 nx111y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*1 0 0 1 1 0 1 1 1 1 0 1 0 0 0 0 0 1 1 0 0 1 1 0 0 0 1 0 0 0
Vinx112y0 nx112y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 1 1 0 1 1 0 1 0 0 1 0 1 0 1 1 1 0 0 0 0 1 1 0 0 0 0 1
Vinx112y1 nx112y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 0 0 0 1 0 1 0 0 0 1 0 0 1 1 1 1 0 1 0 0 0 0 0 0 0 1
Vinx112y2 nx112y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 0 0 1 0 1 1 1 0 0 1 1 0 1 0 0 1 1 1 0 0 1 1 0 0 0 1 0
Vinx112y3 nx112y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 0 0 1 1 1 1 0 0 1 0 1 0 1 0 0 1 0 0 0 0 1 0 0 1 0 1 0 0
Vinx113y0 nx113y0 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 0 1 0 0 1 0 0 1 0 0 1 1 0 0 1 1 1 0 1 1 1 0 0 1 0 0 0 1
Vinx113y1 nx113y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 1 0 0 0 0 1 1 1 1 0 0 1 1 1 1 0 1 1 1 1 1 1 0 0 0 1 1 0 0
Vinx113y2 nx113y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 4501n 0 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0
*0 1 0 0 0 0 0 0 1 0 0 1 0 0 1 0 1 0 1 0 0 1 1 0 1 0 1 0 0 0
Vinx113y3 nx113y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 1 0 0 1 1 0 0 0 1 0 1 0 0 0 0 0 1 0 1 0 0 0 1 0 1 1 0 1 0
Vinx114y0 nx114y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*1 0 0 1 1 0 0 0 0 1 0 1 1 0 1 1 1 1 0 0 0 0 1 1 1 1 1 1 1 0
Vinx114y1 nx114y1 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 0 0 1 0 1 1 1 1 0 0 0 1 1 0 1 0 0 1 0 1 1 0 0 0 1 0 1
Vinx114y2 nx114y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 0 1 1 0 0 1 1 1 0 1 1 1 0 0 1 0 0 1 0 0 1 1 0 1 1 1
Vinx114y3 nx114y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 1 1 1 0 1 1 1 0 1 0 1 1 1 1 1 0 0 1 0 1 0 1 0 0 0 1 0 1 1
Vinx115y0 nx115y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 1 0 0 1 1 0 1 1 1 1 1 0 0 1 0 0 1 1 1 0 0 0 1 1 1 1
Vinx115y1 nx115y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 0 1 0 0 1 0 0 1 1 1 1 0 0 0 1 0 0 1 1 1 0 0 1 0 0 1
Vinx115y2 nx115y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 1 1 0 1 1 0 0 1 0 0 1 0 0 1 1 1 0 0 1 1 1 1 1 1 1 1
Vinx115y3 nx115y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 1 1 1 1 1 0 0 0 1 1 0 1 0 1 1 0 1 1 0 1 1 0 0 0 1 1
Vinx116y0 nx116y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 0 0 1 1 1 1 0 1 0 1 0 0 0 1 0 0 0 0 1 1 0 1 1 0 1 0 1
Vinx116y1 nx116y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*1 0 0 0 0 1 1 1 1 1 1 1 0 1 0 1 0 1 0 1 1 0 1 1 0 1 1 1 0 0
Vinx116y2 nx116y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 14401n 0 15301n 0 16201n 0 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 1 0 1 0 1 1 1 1 0 1 1 1 0 0 0 0 0 0 0 0 0 0 1 1 1 0 1 1 0
Vinx116y3 nx116y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 0 0 1 0 1 0 0 1 0 0 0 1 1 1 0 1 0 0 1 0 0 0 0 1 0 0 1
Vinx117y0 nx117y0 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 1 1 0 1 0 1 1 1 0 1 1 0 0 0 1 1 0 0 0 0 0 0 0 1 1 1 0
Vinx117y1 nx117y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0
*0 0 1 0 0 1 1 0 1 1 0 0 0 0 0 1 1 1 1 1 1 0 0 1 1 1 0 1 1 0
Vinx117y2 nx117y2 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 20701n 0 21601n 0 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 1 1 1 1 1 0 1 0 0 0 0 0 1 1 0 1 1 1 1 0 0 0 0 1 0 1 1
Vinx117y3 nx117y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 0 0 1 0 1 0 1 0 0 0 0 1 0 1 0 0 1 0 0 0 1 0 1 1 1 1 0 1
Vinx118y0 nx118y0 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 1 1 1 0 1 0 1 1 0 0 0 1 1 0 0 0 1 0 1 0 1 0 1 0 0 1
Vinx118y1 nx118y1 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 6301.1n SUPPLY 7200.9n SUPPLY 7201n 0 8101n 0 9001n 0 9901n 0 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 1 1 0 0 0 1 1 0 0 0 0 1 1 0 0 0 1 1 1 0 1 1 1 1 0 0 1 0 1
Vinx118y2 nx118y2 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 1 1 1 1 1 0 1 0 1 1 1 1 0 0 1 0 0 1 1 0 1 1 0 1 0 1 0 1
Vinx118y3 nx118y3 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 6301n 0 7201n 0 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 20701.1n SUPPLY 21600.9n SUPPLY 21601n 0 22501n 0 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 0 0 1 0 0 0 0 0 1 0 0 1 1 1 1 1 1 1 1 0 1 1 0 0 0 1 0 0
Vinx119y0 nx119y0 0 PWL 1n 0 901n 0 1801n 0 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 12601.1n SUPPLY 13500.9n SUPPLY 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 17101.1n SUPPLY 18000.9n SUPPLY 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 0 0 1 0 1 0 0 1 1 0 0 0 1 1 1 0 1 1 1 0 0 0 1 1 1 1 0 1
Vinx119y1 nx119y1 0 PWL 1n 0 901n 0 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 3601n 0 3601.1n SUPPLY 4500.9n SUPPLY 4501n 0 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 8101.1n SUPPLY 9000.9n SUPPLY 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 19801n 0 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 25201.1n SUPPLY 26100.9n SUPPLY 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*0 0 1 0 1 0 1 0 1 1 1 0 0 0 0 1 1 0 1 0 1 0 0 0 1 0 1 0 1 1
Vinx119y2 nx119y2 0 PWL 1n 0 901n 0 901.1n SUPPLY 1800.9n SUPPLY 1801n 0 1801.1n SUPPLY 2700.9n SUPPLY 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9001.1n SUPPLY 9900.9n SUPPLY 9901n 0 10801n 0 11701n 0 11701.1n SUPPLY 12600.9n SUPPLY 12601n 0 13501n 0 14401n 0 14401.1n SUPPLY 15300.9n SUPPLY 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 24301n 0 24301.1n SUPPLY 25200.9n SUPPLY 25201n 0 26101n 0
*0 1 1 1 0 1 1 0 1 0 1 0 0 1 0 0 1 1 1 0 1 1 1 0 0 1 0 1 0 0
Vinx119y3 nx119y3 0 PWL 1n 0 1.1n SUPPLY 900.9n SUPPLY 901n 0 1801n 0 2701n 0 2701.1n SUPPLY 3600.9n SUPPLY 3601n 0 4501n 0 4501.1n SUPPLY 5400.9n SUPPLY 5401n 0 5401.1n SUPPLY 6300.9n SUPPLY 6301n 0 7201n 0 7201.1n SUPPLY 8100.9n SUPPLY 8101n 0 9001n 0 9901n 0 9901.1n SUPPLY 10800.9n SUPPLY 10801n 0 10801.1n SUPPLY 11700.9n SUPPLY 11701n 0 12601n 0 13501n 0 13501.1n SUPPLY 14400.9n SUPPLY 14401n 0 15301n 0 15301.1n SUPPLY 16200.9n SUPPLY 16201n 0 16201.1n SUPPLY 17100.9n SUPPLY 17101n 0 18001n 0 18001.1n SUPPLY 18900.9n SUPPLY 18901n 0 18901.1n SUPPLY 19800.9n SUPPLY 19801n 0 19801.1n SUPPLY 20700.9n SUPPLY 20701n 0 21601n 0 21601.1n SUPPLY 22500.9n SUPPLY 22501n 0 22501.1n SUPPLY 23400.9n SUPPLY 23401n 0 23401.1n SUPPLY 24300.9n SUPPLY 24301n 0 25201n 0 26101n 0 26101.1n SUPPLY 27000.9n SUPPLY
*1 0 0 1 0 1 1 0 1 0 0 1 1 0 0 1 0 1 1 0 1 1 1 0 1 1 1 0 0 1
